# Keil uVision project ESP-AT-FreeRTOS-Library-M487.uvprojx, settings and files
target M487JIDAE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: ESP-AT-FreeRTOS-Library-M487
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: LWRB_DISABLE_ATOMIC
  c include: .\Application\Inc;.\Application\Src;.\Library\Inc;.\Library\Src;..\M480_BSP\Library\StdDriver\inc;..\M480_BSP\Library\StdDriver\src;..\M480_BSP\ThirdParty\FreeRTOS\Source\include;..\M480_BSP\ThirdParty\FreeRTOS\Source\portable\MemMang;..\M480_BSP\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\M480_BSP\ThirdParty\FreeRTOS\Demo\Common\include;..\M480_BSP\ThirdParty\lwesp\lwesp\config;..\M480_BSP\ThirdParty\lwesp\lwesp\include;..\M480_BSP\ThirdParty\lwesp\lwesp\source;..\M480_BSP\ThirdParty\lwrb\lwrb\src\include;..\M480_BSP\ThirdParty\lwrb\lwrb\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Application
    ./Application/Src/: main.c
    ./Application/Inc/: main.h FreeRTOSConfig.h
  group StdLibrary
    ../M480_BSP/Library/StdDriver/src/: sys.c clk.c gpio.c uart.c pdma.c
  group ThirdParty/FreeRTOS
    ../M480_BSP/ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../M480_BSP/ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../M480_BSP/ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group ThirdParty/lwesp
    ../M480_BSP/ThirdParty/lwesp/lwesp/config/: lwesp_config.h
    ../M480_BSP/ThirdParty/lwesp/lwesp/include/: lwesp.h lwesp_include.h lwesp_typedef.h lwesp_ll_m480.h lwesp_at_basic.h lwesp_sys.h lwesp_queue.h
    ../M480_BSP/ThirdParty/lwesp/lwesp/source/: lwesp.c lwesp_ll_m480.c lwesp_at_basic.c lwesp_sys.c lwesp_queue.c
software components: CMSIS:CORE 5.6.0, Device:Startup 0.00.001
